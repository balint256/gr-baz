<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>borip_usrp_uhd</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adc_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>64000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>side</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>"A"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>adc_freq/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda: self.master_clock()/self.source._get_u().decim_rate()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>set_samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda r: self.source.set_decim_rate(self.master_clock()//r)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>unit</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Unit</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>addr</value></param>
<param><key>label</key><value>Address</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>side</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Side</value></param>
<param><key>value</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>subdev</value></param>
<param><key>label</key><value>Sub Dev</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antenna</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>"TX/RX"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>set_antenna</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda a: self.source._subdev.select_rx_antenna(a)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>antennas</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>["TX/RX","RX2","RXA","RXB","RXAB"]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>master_clock</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda: self.source._get_u().fpga_master_clock_freq()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_range</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda: self.source._subdev.gain_range()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>set_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda f: self.tr_to_list(f, self.source._get_u().tune(0, self.source._subdev, f))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_tolerance</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>usrp_simple_source_x</key>
<param><key>id</key><value>source_legacy</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>format</key><value></value></param>
<param><key>which</key><value>unit</value></param>
<param><key>decimation</key><value>256</value></param>
<param><key>frequency</key><value>0</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>side</key><value>side</value></param>
<param><key>rx_ant</key><value></value></param>
<param><key>hb_filters</key><value></value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>serial</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda: self.source._get_u().serial_number()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_name</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda: "USRP (" + serial() + ")"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>serial</value></param>
<param><key>value</key><value>lambda: self.source.get_usrp_info().get("mboard_serial")</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>source_name</value></param>
<param><key>value</key><value>lambda: "USRP (" + self.source.get_usrp_info().get("mboard_id") + ")"</value></param>
</block>
<block>
<key>gr_null_source</key>
<param><key>id</key><value>gr_null_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tr_to_list</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda req, tr: [req, tr.baseband_freq, tr.dxc_freq + tr.residual_freq, tr.dxc_freq]</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_items</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>baz_udp_sink</key>
<param><key>id</key><value>sink</value></param>
<param><key>type</key><value>short</value></param>
<param><key>ipaddr</key><value></value></param>
<param><key>port</key><value>28888</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>borip</key><value>True</value></param>
<param><key>status_in</key><value>False</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>source</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>dev_addr</key><value>addr</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>subdev</value></param>
<param><key>samp_rate</key><value>0</value></param>
<param><key>center_freq0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
</block>
<connection><source_block_id>gr_null_source_0</source_block_id><sink_block_id>sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>source</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>source</source_block_id><sink_block_id>gr_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0</source_block_id><sink_block_id>sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>source</source_block_id><sink_block_id>sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
