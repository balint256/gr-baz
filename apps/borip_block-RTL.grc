<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>borip_RTL</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>BorIP</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>variable_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_step</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain_range</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>lambda: self.source.gain_range()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>buf</value></param>
<param><key>label</key><value>Buffer</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tuner</value></param>
<param><key>label</key><value>Tuner</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>baz_message_callback</key>
<param><key>id</key><value>status</value></param>
<param><key>name</key><value>Descriptive name</value></param>
<param><key>dummy</key><value>True</value></param>
<param><key>msg_part</key><value>arg1</value></param>
<param><key>custom_parts</key><value></value></param>
<param><key>target</key><value>0</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>source</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>type</key><value>short</value></param>
<param><key>sample_rate</key><value>1000000</value></param>
<param><key>frequency</key><value>0</value></param>
<param><key>bandwidth</key><value>0</value></param>
<param><key>relative_gain</key><value>False</value></param>
<param><key>gain</key><value>0</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>auto_gain_mode</key><value>False</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>tuner_name</key><value>tuner</value></param>
<param><key>read_length</key><value>readlen</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
<param><key>use_buffer</key><value>buf</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>xtal_freq</key><value>0</value></param>
<param><key>status_out</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>readlen</value></param>
<param><key>label</key><value>ReadLen</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>master_clock</value></param>
<param><key>value</key><value>3200000</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>16384*2*0+128</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_interleaved_short</key>
<param><key>id</key><value>gr_complex_to_interleaved_short_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<connection><source_block_id>source</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>source</source_block_id><sink_block_id>status</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>source</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_complex_to_interleaved_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_interleaved_short_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
