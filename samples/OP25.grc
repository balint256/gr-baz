<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>op25_grc</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>audio_mul</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Audio mul</value></param>
<param><key>max</key><value>20</value></param>
<param><key>min</key><value>-40</value></param>
<param><key>num_steps</key><value>60</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>auto_tune_offset</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>auto_tune_offset_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>auto_tune_offset*baz_op25.SYMBOL_DEVIATION</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Auto tune</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_rate</value></param>
<param><key>value</key><value>baz_op25.SYMBOL_RATE*samp_per_sym</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>click_freq</value></param>
<param><key>value</key><value>freq-config_xlate_offset</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_freq</value></param>
<param><key>config_file</key><value>.grc_op25</value></param>
<param><key>value</key><value>434075000</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_bandwidth</value></param>
<param><key>config_file</key><value>.grc_op25</value></param>
<param><key>value</key><value>24000</value></param>
<param><key>option</key><value>xlate_bandwidth</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>xlate_bandwidth</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_offset</value></param>
<param><key>config_file</key><value>.grc_op25</value></param>
<param><key>value</key><value>0</value></param>
<param><key>option</key><value>xlate_offset</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>xlate_offset+xlate_offset_fine</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>final_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq+xlate_offset+xlate_offset_fine+auto_tune_offset</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Final freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fine_click_freq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>config_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Frequency</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>20</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>max</key><value>50</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>idle_silence</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Output idle silence</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>key_map</value></param>
<param><key>value</key><value>{0x0001: "0123456789ABCDEF"}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_channel_rate</value></param>
<param><key>value</key><value>samp_rate/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000*0+250000</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>variable_any_code_0</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.set_auto_tune_offset_freq(0.0)</value></param>
<param><key>value</key><value>None</value></param>
<param><key>first_eval</key><value>none</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'click_freq':click_freq, 'fine_click_freq':fine_click_freq}</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>verbose</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Verbose console logging</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_bandwidth</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>config_xlate_bandwidth</value></param>
<param><key>label</key><value>Xlate BW</value></param>
<param><key>max</key><value>50000</value></param>
<param><key>min</key><value>5000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq-click_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Xlate Offset</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Fine Offset</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>(channel_rate/(2.0 * math.pi * baz_op25.SYMBOL_DEVIATION))</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>baz_message_callback</key>
<param><key>id</key><value>baz_message_callback_0</value></param>
<param><key>custom_parts</key><value></value></param>
<param><key>consume_dummy</key><value>False</value></param>
<param><key>dummy</key><value>False</value></param>
<param><key>eval_mode</key><value>raw</value></param>
<param><key>msg_part</key><value>arg1</value></param>
<param><key>name</key><value>auto_tune_offset</value></param>
<param><key>print_stdout</key><value>False</value></param>
<param><key>target</key><value>auto_tune_offset</value></param>
</block>
<block>
<key>baz_udp_sink</key>
<param><key>id</key><value>baz_udp_sink_0</value></param>
<param><key>status_in</key><value>False</value></param>
<param><key>borip</key><value>True</value></param>
<param><key>ipaddr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>1234</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>psize</key><value>1472</value></param>
<param><key>eof</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/Users/balint/Music/BOR+10khz_P25_250000sps.cfile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>10.**(1.*audio_mul/20.)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>(1.0/samp_per_sym,)*samp_per_sym</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-(xlate_offset+xlate_offset_fine-fine_click_freq-auto_tune_offset_freq)</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, xlate_bandwidth/2, 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>from baz import baz_op25</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>labels</key><value>['BB-1','BB-2','Xlate-1','Xlate-2','4FSK','Dibits','Audio']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Enable your source!</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Can use LO offset with UHD instead of offset tuning and Xlating back</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Boxcar is better (?)</value></param>
</block>
<block>
<key>op25_decoder</key>
<param><key>id</key><value>op25_decoder_0</value></param>
<param><key>channel_rate</key><value>channel_rate</value></param>
<param><key>verbose</key><value>verbose</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>idle_silence</key><value>idle_silence</value></param>
<param><key>key</key><value></value></param>
<param><key>key_map</key><value>key_map</value></param>
<param><key>dibits_out</key><value>True</value></param>
<param><key>msg_out</key><value>traffic</value></param>
</block>
<block>
<key>op25_decoder_bf</key>
<param><key>id</key><value>op25_decoder_bf_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>op25_decoder_ff</key>
<param><key>id</key><value>op25_decoder_ff_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>op25_decoder_simple</key>
<param><key>id</key><value>op25_decoder_simple_0</value></param>
<param><key>verbose</key><value>verbose</value></param>
<param><key>idle_silence</key><value>idle_silence</value></param>
<param><key>key</key><value></value></param>
<param><key>key_map</key><value>key_map</value></param>
<param><key>traffic_out</key><value>True</value></param>
</block>
<block>
<key>op25_fsk4</key>
<param><key>id</key><value>op25_fsk4_0</value></param>
<param><key>channel_rate</key><value>channel_rate</value></param>
<param><key>tune_out</key><value>True</value></param>
</block>
<block>
<key>op25_fsk4_demod_ff</key>
<param><key>id</key><value>op25_fsk4_demod_ff_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>sample_rate</key><value>channel_rate</value></param>
<param><key>symbol_rate</key><value>baz_op25.SYMBOL_RATE</value></param>
</block>
<block>
<key>op25_fsk4_slicer_fb</key>
<param><key>id</key><value>op25_fsk4_slicer_fb_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>op25_traffic_pane</key>
<param><key>id</key><value>op25_traffic_pane_0</value></param>
<param><key>reset</key><value>0</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>pre_channel_rate</value></param>
<param><key>interp</key><value>channel_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>baz_op25.AUDIO_RATE</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>0.35</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>11*int(channel_rate/baz_op25.SYMBOL_RATE)</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>sym_rate</key><value>baz_op25.SYMBOL_RATE</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>rtl2832_source_0</value></param>
<param><key>auto_gain_mode</key><value>False</value></param>
<param><key>bandwidth</key><value>0</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>xtal_freq</key><value>0</value></param>
<param><key>tuner_name</key><value></value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>status_out</key><value>False</value></param>
<param><key>relative_gain</key><value>True</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>use_buffer</key><value>True</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>read_length</key><value>1024*128*2</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>stream_immediately</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>click_freq</value></param>
<param><key>freq_of_interest</key><value>float('inf')</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-30</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold_level</key><value>float('inf')</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>fine_click_freq</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>freqvar</key><value>fine_click_freq</value></param>
<param><key>freq_of_interest</key><value>float('inf')</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 2</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>-30</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>threshold_level</key><value>float('inf')</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb, 5</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>baz_op25.SYMBOL_RATE</value></param>
<param><key>t_scale</key><value>0.05</value></param>
<param><key>title</key><value>Dibits</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>1</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb, 4</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>t_scale</key><value>0.05</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>1.5</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_2</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb, 6</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>baz_op25.AUDIO_RATE</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Audio</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-30</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 3</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>ref_level</key><value>-30</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>None</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>op25_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>op25_fsk4_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>op25_fsk4_demod_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_0</source_block_id><sink_block_id>wxgui_scopesink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_0</source_block_id><sink_block_id>baz_message_callback_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>op25_decoder_0</source_block_id><sink_block_id>op25_traffic_pane_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>op25_decoder_bf_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_bf_0</source_block_id><sink_block_id>wxgui_scopesink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_ff_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_ff_0</source_block_id><sink_block_id>wxgui_scopesink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_simple_0</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_simple_0</source_block_id><sink_block_id>wxgui_scopesink2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_decoder_simple_0</source_block_id><sink_block_id>op25_traffic_pane_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>op25_fsk4_0</source_block_id><sink_block_id>baz_udp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_0</source_block_id><sink_block_id>op25_decoder_simple_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_0</source_block_id><sink_block_id>op25_fsk4_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_0</source_block_id><sink_block_id>baz_message_callback_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>op25_fsk4_demod_ff_0</source_block_id><sink_block_id>op25_decoder_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_demod_ff_0</source_block_id><sink_block_id>op25_decoder_simple_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_demod_ff_0</source_block_id><sink_block_id>op25_fsk4_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_demod_ff_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_demod_ff_0</source_block_id><sink_block_id>baz_message_callback_0</sink_block_id><source_key>msg</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>op25_fsk4_slicer_fb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>op25_fsk4_slicer_fb_0</source_block_id><sink_block_id>op25_decoder_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>op25_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
