<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Fine Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine</value></param>
<param><key>label</key><value>Fine Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_bandwidth</value></param>
<param><key>label</key><value>Xlate BW</value></param>
<param><key>value</key><value>config_xlate_bandwidth</value></param>
<param><key>min</key><value>5000</value></param>
<param><key>max</key><value>50000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>config_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-100000</value></param>
<param><key>max</key><value>100000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pre_channel_rate</value></param>
<param><key>value</key><value>samp_rate/decim</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset</value></param>
<param><key>label</key><value>Xlate Offset</value></param>
<param><key>value</key><value>config_xlate_offset</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_rtl</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>xlate_offset</value></param>
<param><key>writeback</key><value>xlate_offset+xlate_offset_fine</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_freq</value></param>
<param><key>value</key><value>434075000</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_rtl</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>freq</value></param>
<param><key>writeback</key><value>freq</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_bandwidth</value></param>
<param><key>value</key><value>24000</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_rtl</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>xlate_bandwidth</value></param>
<param><key>writeback</key><value>xlate_bandwidth</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>audio_mul</value></param>
<param><key>label</key><value>Audio mul</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_rate</value></param>
<param><key>value</key><value>24000</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, xlate_bandwidth/2, 1000)</value></param>
<param><key>center_freq</key><value>xlate_offset+xlate_offset_fine</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>freq</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>12000</value></param>
</block>
<block>
<key>gr_pwr_squelch_xx</key>
<param><key>id</key><value>gr_pwr_squelch_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>1e-3</value></param>
<param><key>ramp</key><value>0</value></param>
<param><key>gate</key><value>True</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['BB-1','BB-2','Xlate-1','Xlate-2','Audio','FFT']</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb, 2</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb, 3</value></param>
</block>
<block>
<key>blks2_nbfm_rx</key>
<param><key>id</key><value>blks2_nbfm_rx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>quad_rate</key><value>channel_rate</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>6e3</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_1</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>pre_channel_rate</value></param>
<param><key>interp</key><value>channel_rate</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>gr_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>channel_rate/(2*math.pi*6000)</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>nb, 5</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>2</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>cutoff_freq</key><value>6000</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>rtl2832_source</key>
<param><key>id</key><value>rtl2832_source_0</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>bandwidth</key><value>0</value></param>
<param><key>relative_gain</key><value>True</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>gain_mode</key><value></value></param>
<param><key>auto_gain_mode</key><value>False</value></param>
<param><key>usb_vid</key><value>0x0</value></param>
<param><key>usb_pid</key><value>0x0</value></param>
<param><key>tuner_name</key><value></value></param>
<param><key>read_length</key><value>1024*128*2</value></param>
<param><key>xfer_timeout</key><value>0</value></param>
<param><key>use_buffer</key><value>True</value></param>
<param><key>buf_mul</key><value>0</value></param>
<param><key>buf_level</key><value>0</value></param>
<param><key>fir_coeffs</key><value>[]</value></param>
<param><key>xtal_freq</key><value>0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>nb, 4</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>decim</key><value>audio_rate</value></param>
<param><key>interp</key><value>48000*0+44100</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>audio_mul</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>44100</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtl2832_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>blks2_nbfm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_nbfm_rx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_nbfm_rx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_nbfm_rx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_1</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
