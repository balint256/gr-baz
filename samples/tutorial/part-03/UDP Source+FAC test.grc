<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>adc_rate</value></param>
<param><key>value</key><value>64000000</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>xlate_decim</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Xlate Decim</value></param>
<param><key>value</key><value>2**xlate_decim_index</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>decim</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Decimation</value></param>
<param><key>value</key><value>64</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_decim_index</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Xlate Decim</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>8</value></param>
<param><key>num_steps</key><value>9</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>adc_rate/decim</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_bandwidth</value></param>
<param><key>label</key><value>Xlate BW</value></param>
<param><key>value</key><value>config_xlate_bandwidth</value></param>
<param><key>min</key><value>12500</value></param>
<param><key>max</key><value>500000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>main_notebook,0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>baseband_rate</value></param>
<param><key>label</key><value>BB Rate</value></param>
<param><key>value</key><value>samp_rate/xlate_decim</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>main_notebook,0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_bandwidth</value></param>
<param><key>value</key><value>min(baseband_rate,500000)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_udp_fac</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>xlate_bandwidth</value></param>
<param><key>writeback</key><value>xlate_bandwidth</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>xlate_offset_fine</value></param>
<param><key>label</key><value>Fine Offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-10000</value></param>
<param><key>max</key><value>10000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>main_notebook,0</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>v_scale</key><value>10</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0.001</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>main_notebook,1</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>30</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.25</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>main_notebook,0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_decim</value></param>
<param><key>value</key><value>16*0+4</value></param>
</block>
<block>
<key>xmlrpc_server</key>
<param><key>id</key><value>xmlrpc_server_0</value></param>
<param><key>addr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>8080</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>main_notebook</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['BB', 'Demod','Xtra','FAC','Waterfall','Quad']</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>gr_freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>xlate_decim</value></param>
<param><key>taps</key><value>firdes.low_pass(1, samp_rate, xlate_bandwidth/2, 1000)</value></param>
<param><key>center_freq</key><value>xlate_offset+xlate_offset_fine</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>dynamic_range</key><value>100</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>25</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>main_notebook,4</value></param>
</block>
<block>
<key>facsink</key>
<param><key>id</key><value>facsink_0</value></param>
<param><key>title</key><value>Fast AutoCorrelation</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>fac_size</key><value>512*2*8*16</value></param>
<param><key>fac_rate</key><value>10</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>ref_level</key><value>50</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>notebook</key><value>main_notebook,3</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>baseband_rate</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>notebook</key><value>main_notebook,5</value></param>
</block>
<block>
<key>gr_quadrature_demod_cf</key>
<param><key>id</key><value>gr_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>wxgui_constellationsink2</key>
<param><key>id</key><value>wxgui_constellationsink2_0</value></param>
<param><key>title</key><value>Constellation Plot</value></param>
<param><key>samp_rate</key><value>54000</value></param>
<param><key>frame_rate</key><value>15</value></param>
<param><key>const_size</key><value>2048</value></param>
<param><key>M</key><value>4</value></param>
<param><key>theta</key><value>3.141592/4</value></param>
<param><key>alpha</key><value>0.005</value></param>
<param><key>fmax</key><value>0.06</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>0.005</value></param>
<param><key>symbol_rate</key><value>18000</value></param>
<param><key>omega_limit</key><value>0.005</value></param>
<param><key>notebook</key><value>main_notebook,2</value></param>
</block>
<block>
<key>blks2_rational_resampler_xxx</key>
<param><key>id</key><value>blks2_rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>625*0+baseband_rate</value></param>
<param><key>interp</key><value>54000</value></param>
<param><key>taps</key><value>[]</value></param>
<param><key>fractional_bw</key><value>0</value></param>
</block>
<block>
<key>gr_interleaved_short_to_complex</key>
<param><key>id</key><value>gr_interleaved_short_to_complex_0</value></param>
</block>
<block>
<key>gr_udp_source</key>
<param><key>id</key><value>gr_udp_source_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>ipaddr</key><value>0.0.0.0</value></param>
<param><key>port</key><value>1234*0+28888</value></param>
<param><key>psize</key><value>1472*0+16384</value></param>
<param><key>eof</key><value>True</value></param>
<param><key>wait</key><value>True</value></param>
<param><key>borip</key><value>True</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0</value></param>
<param><key>type</key><value>short</value></param>
<param><key>num_items</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>xlate_offset</value></param>
<param><key>label</key><value>Xlate Offset</value></param>
<param><key>value</key><value>config_xlate_offset</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>main_notebook,0</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>config_xlate_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>.grc_udp_fac</value></param>
<param><key>section</key><value>main</value></param>
<param><key>option</key><value>xlate_offset</value></param>
<param><key>writeback</key><value>xlate_offset</value></param>
</block>
<connection><source_block_id>gr_udp_source_0</source_block_id><sink_block_id>gr_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0</source_block_id><sink_block_id>gr_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_interleaved_short_to_complex_0</source_block_id><sink_block_id>gr_freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>facsink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_rational_resampler_xxx_0</source_block_id><sink_block_id>wxgui_constellationsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks2_rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>gr_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_quadrature_demod_cf_0</source_block_id><sink_block_id>wxgui_scopesink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
